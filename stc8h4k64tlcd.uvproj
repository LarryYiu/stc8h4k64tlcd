# Keil uVision project stc8h4k64tlcd.uvproj, settings and files
target stc8h (MCS-51)
  device: STC8H4K64TLCD Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x0FFF) IROM(0-0xFFF8) CLOCK(45000000)
  output: stc8h4k64tlcd +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\APP;.\DRIVER;.\STC8H_LIB;.\LIB
  group APP
    ./: STARTUP.A51
    ./APP/: main.c UartISR.c AppFunctionSetup.c TimerISR.c I2C_ISR.c
  group DRIVER
    ./DRIVER/: AT24C02.c
  group STC8H_LIB
    ./STC8H_LIB/: STC8G_H_GPIO.c STC8G_H_NVIC.c STC8G_H_UART.c STC8G_H_Switch.h STC8G_H_Timer.c STC8G_H_I2C.c STC8G_H_ADC.c STC8G_H_Delay.c
  group LIB
    ./LIB/: GPIO.c UART.c Timer.c I2C.c ADC.c Utility.c
